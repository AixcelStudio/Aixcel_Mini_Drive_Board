# IAR project Aixcel_Mini_Drive_Board_MCU.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Aixcel_Mini_Drive_Board_MCU.out
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: AT32F403ACGT7 ArteryTek AT32F403ACGT7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: NDEBUG; AT32F403ACGT7; USE_STDPERIPH_DRIVER; AT_START_F403A_V1_0
  ICCARM.CCIncludePath2: ..\Drivers\CMSIS\CM4\CoreSupport; ..\Drivers\CMSIS\CM4\DeviceSupport; ..\Drivers\AT32F4xx_StdPeriph_Driver\inc; ..\Drivers\AT32_USB-FS-Device_Driver\inc; ..\Inc; ..\Src\usb_vcp\inc; ..\Middleware\UART_Drv; ..\Middleware\Task_Drv; ..\Middleware\Enet_Drv; ..\Middleware\Timer_Drv; ..\Middleware\GD25Qxx_Drv; ..\Middleware\CAN_Drv; ..\Middleware\SW_I2C_Drv; ..\Middleware\LSM6DSL_Drv; ..\Middleware\QMI8658C_Drv; ..\Middleware\SPL06_001_Drv
  ICCARM.CCOptLevel: 0
  OBJCOPY.OOCOutputFile: Aixcel_Mini_Drive_Board_MCU.hex
  ILINK.IlinkIcfFile: AT32F403AxG.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../Drivers/CMSIS/CM4/DeviceSupport/startup/iar/: startup_at32f403acgt7.s
  group Application/Middleware/CAN_Drv
    ../Middleware/CAN_Drv/: can_drv.c
  group Application/Middleware/Enet_Drv
    ../Middleware/Enet_Drv/: enet_drv.c
  group Application/Middleware/GD25Qxx_Drv
    ../Middleware/GD25Qxx_Drv/: gd25qxx_drv.c
  group Application/Middleware/LSM6DSL_Drv
    ../Middleware/LSM6DSL_Drv/: lsm6dsl_reg.c
  group Application/Middleware/QMI8658C_Drv
    ../Middleware/QMI8658C_Drv/: qmi8658c_drv.c
  group Application/Middleware/SPL06_001_Drv
    ../Middleware/SPL06_001_Drv/: spl06_001_drv.c
  group Application/Middleware/SW_I2C_Drv
    ../Middleware/SW_I2C_Drv/: simulate_i2c.c
  group Application/Middleware/Task_Drv
    ../Middleware/Task_Drv/: task.c
  group Application/Middleware/Timer_Drv
    ../Middleware/Timer_Drv/: timer.c
  group Application/Middleware/UART_Drv
    ../Middleware/UART_Drv/: uart_drv.c
  group Application/User
    ../Src/: at32f4xx_it.c barometer_process.c common.c endian_test.c hwconf.c imu_crtl_process.c imu_crtl_process_qst.c m485_ctrl_process.c main.c mbcrc.c sendwave.c spi_flash_process.c systick.c
  group Application/User/USB_VCP
    ../Src/usb_vcp/src/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group Drivers/AT32_USB-FS-Device_Driver
    ../Drivers/AT32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group Drivers/AT32F4xx_StdPeriph_Driver
    ../Drivers/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_acc.c at32f4xx_adc.c at32f4xx_bkp.c at32f4xx_can.c at32f4xx_comp.c at32f4xx_crc.c at32f4xx_dac.c at32f4xx_dbgmcu.c at32f4xx_dma.c at32f4xx_ertc.c at32f4xx_eth.c at32f4xx_exti.c at32f4xx_flash.c at32f4xx_gpio.c at32f4xx_gpio_ex.c at32f4xx_i2c.c at32f4xx_iwdg.c at32f4xx_pwr.c at32f4xx_rcc.c at32f4xx_rtc.c at32f4xx_sdio.c at32f4xx_spi.c at32f4xx_syscfg.c at32f4xx_tim.c at32f4xx_usart.c at32f4xx_wwdg.c at32f4xx_xmc.c misc.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/CM4/DeviceSupport/: system_at32f4xx.c
